# Keil uVision project AIAOMASTER.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: ver1_0_AIAOM +hex
  c flags: Optimize=8
  group Source Group 1
    ./: ver1_0.c
  group System files
    C:/Keil/C51/LIB/: STARTUP.A51
